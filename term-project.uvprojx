# Keil uVision project term-project.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: term-project
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.s Startup.s ISR_Handler.s Led_Module_init.s Microphone_Module_init.s Motor_Module_init.s Screen_Module_init.s POT_Threshold_Module.s Led_Module.s Microphone_Module.s Screen_Module.s Screen_Table.s Screen_Table2.s Screen_Table3.s Delay_Module.s Convrt.s OutStr.s
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev
